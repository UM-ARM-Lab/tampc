Commit message: Analyze forces during push simulation steps

File: pusher.urdf (robot description, URDF)
Before this commit: robot pusher, 1 links, 0 joints
Links:
- link base_link: mass 10.02 -> 6.0
